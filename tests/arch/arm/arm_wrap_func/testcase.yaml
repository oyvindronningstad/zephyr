## tests/arch/arm/arm_wrap_func/testcase.yaml
```yaml
tests:
  arch.wrap_func.arm:
    tags: arm wrap_func
    filter: CONFIG_CPU_CORTEX_M
```
